# IAR project 405_PA_Driver.ewp, settings and files
configuration 405_PA_Driver (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..; C:\Users\Sergey\YandexDisk\Work\Utilities\Libraries\boost_1_78_0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: 405_PA_Driver.hex
  ILINK.IlinkOutputFile: 405_PA_Driver.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../App/: signal_generator.a
  group Application/User/App/c_interface
    ../App/c_interface/: sig_gen_interface.cpp sig_gen_interface.h
  group Application/User/App/pwm_controller
    ../App/pwm_controller/: pwm_controller.cpp pwm_controller.hpp
  group Application/User/App/pwm_generator
    ../App/pwm_generator/: pwm_generator.cpp pwm_generator.hpp
  group Application/User/App/pwm_os_tasks
    ../App/pwm_os_tasks/: pwm_os_tasks.cpp pwm_os_tasks.hpp
  group Application/User/App/signal_generator
    ../App/signal_generator/: signal_generator.cpp signal_generator.hpp
  group Application/User/App/signals
    ../App/signals/: signals.cpp signals.hpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c crc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
